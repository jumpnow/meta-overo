FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://avahi-daemon-conf.patch"

