PACKAGECONFIG:remove = "gstreamer python2 python3 samples v4l libv4l"
