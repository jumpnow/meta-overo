# PACKAGECONFIG:remove = "gapi gphoto2 gstreamer gtk jpeg python2 python3 samples tbb tiff v4l libv4l"
PACKAGECONFIG:remove = "gstreamer python2 python3 samples v4l libv4l"
