PACKAGECONFIG_append = " swanctl"

# FILES_${PN} += "${systemd_system_unitdir}"
